# IAR project STM32N6570-DK-FreeRTOS_Appli.ewp, settings and files
configuration STM32N6570-DK-FreeRTOS_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../../Appli/TouchGFX/App; ../../Appli/TouchGFX/target/generated; ../../Appli/TouchGFX/target; ../../Appli/Core/Inc; ../../Secure_nsclib; ../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../Drivers/CMSIS/Include; ../../Appli/Middlewares/ST/touchgfx/framework/include; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/include; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/include; ../../Middlewares/Third_Party/FreeRTOS/Source/include/; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../../Middlewares/Third_Party/CMSIS/RTOS2/Include/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../../Appli/Core/Inc; ../../Appli/TouchGFX/App; ../../Appli/TouchGFX/target/generated; ../../Appli/TouchGFX/target; ../../Secure_nsclib; ../../Middlewares/Third_Party/FreeRTOS/Source/include/; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../../Middlewares/Third_Party/CMSIS/RTOS2/Include/; ../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: STM32N6570-DK-FreeRTOS_Appli.bin
  ILINK.IlinkOutputFile: STM32N6570-DK-FreeRTOS_Appli.out
  ILINK.IlinkIcfFile: stm32n657xx_LRUN.icf
  ILINK.IlinkAdditionalLibs: ../../Appli/Middlewares/ST/touchgfx/lib/core/cortex_m55/IAR9.x/touchgfx_core.a; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/lib/core/cortex_m55/IAR9.x/nemagfx_core_release.a; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/lib/cortex_m55/IAR9.x/touchgfx_nema_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx.s
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: main.c app_freertos.c stm32n6xx_it.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c secure_nsc.c
  group Application/User/Appli/TouchGFX/App
    ../../Appli/TouchGFX/App/: app_touchgfx.c
  group Application/User/Appli/TouchGFX/target
    ../../Appli/TouchGFX/target/: CortexMMCUInstrumentation.cpp KeySampler.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/Appli/TouchGFX/target/generated
    ../../Appli/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp HardwareMJPEGDecoder.cpp nema_hal.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_crc.c stm32n6xx_hal_crc_ex.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_gpu2d.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_icache.c stm32n6xx_hal_jpeg.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rif.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Secure_Only
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/: portasm.s port.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
